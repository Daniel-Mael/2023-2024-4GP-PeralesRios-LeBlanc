# Repository Daniel-Mael/2023-2024-4GP-PeralesRios-LeBlanc

File README.md:

# 2023-2024-4gp-Perales_Rios-Le_Blanc

L'objectif de ce projet est d'étudier une technologie de capteur low-tech à base de graphite, en nous basant sur la publication "Pencil Drawn Strain Gauges and Chemiresistors on Paper" de Cheng-Wei Lin*, Zhibo Zhao*, Jaemyung Kim & Jiaxing Huang.
Selon ces travaux de recherche, les particules de graphite, déposées en coloriant une trace de capteur, peuvent agir en jauge de contrainte. 
Ainsi, ce projet balayera l’ensemble du domaine du capteur jusqu’à la réalisation d’une datasheet et du banc de test associé à ce capteur. 

/// ordre des parties à revoir \\\
## 1) Livrables

Plusieurs livrables sont attendus pour ce projet. 

## 2) Matériel nécessaire

Pour réaliser ce projet, nous avons eu besoin de : 
  - 
  -
  -
  -
  -
  -

## ??) Circuit amplificateur 

## ??) Capteur Graphite

/// Mettre schéma du capteur \\\
 Schéma du capteur utilisé lors du projet. Il sera rempli à l'aide de différents types de crayons de papiers. 

## ??) Ecran OLED
La page principale de l'écran OLED présente 3 menus différents : Calibration, Flex Sensor et Graphite Sensor. L'utilisateur peut choisir le menu à l'aide de l'encodeur rotatif. En tournant le bouton les différents menus déroulent et en appuyant sur le bouton l'utilisateur rentre dans un menu spécifique. 

#### Menu Calibration :
Dans ce menu, l'utilisateur choisit la valeur de résistance à donner au potentiomètre en plaçant le curseur sur les valeurs disponibles. L'utilisateur quitte le menu calibration en appuyant sur le bouton de l'encodeur. 
#### Menu Flex Sensor :
Dans ce menu, la valeur de la résistance et la valeur de l'angle du Flex Sensor sont affichées.  
#### Menu Flex Sensor :
Dans ce menu, la valeur de la résistance du capteur à base de graphite est affichée. 

## ??) Application Android

## ??) Création du PCB avec KiCAD

## ??) Shield Arduino

## ??) Banc de test 

## ??) Datasheet

## TODO List

- [x] Create repository on MOSH-Insa-Toulouse organization
- [x] Add KiCad project with version 7.0.10
- [x] Create KiCad schematic
- [x] Add Arduino project

## KiCad design KiCAD/Capteur_Graphite/Capteur_Graphite.kicad_pcb

Parts:
BT1: Bluetooth
C1, C3: 100N; C_Radial_D5.0mm_H5.0mm_P2.00mm
C2: 100n; C_Radial_D5.0mm_H5.0mm_P2.00mm
C4: 1u; C_Radial_D5.0mm_H5.0mm_P2.00mm
EncodRot2: Encodeur
Flex_sensor2: FLEX
J1: Power; PinSocket_1x08_P2.54mm_Vertical
J2: Digital/PWM; PinSocket_1x10_P2.54mm_Vertical
J3: Analog; PinSocket_1x06_P2.54mm_Vertical
J4: Digital/PWM; PinSocket_1x08_P2.54mm_Vertical
MCP2: MCP41050
OLED1: OLED
R1: 100K; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R3: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R5: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R6: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R12: 56.4K; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
U1: LTC1050
capteur_graphite1: Capteur_graphite

Connections:
+3V3: J1.4
/7: J4.1
/8: J2.10
/12: J2.6
/*3: J4.5
/*6: J4.2
/*9: J2.9
/A2: J3.3
/A3: J3.4
/AREF: J2.3
/IOREF: J1.2
/~RESET: J1.3
A0: C2.2, J3.1, R6.2
A1: Flex_sensor2.2 (GND), J3.2, R12.2
D2: EncodRot2.1 (CLK), J4.6
D4: EncodRot2.2 (DT), J4.4
D5: EncodRot2.3 (SW), J4.3
GND: BT1.2 (GND), C1.2, C2.1, C3.2, EncodRot2.5 (GND), J1.6, J1.7, J2.4, MCP2.4 (GND), MCP2.5 (A), MCP2.6 (W), OLED1.2 (GND), R1.2, R12.1, U1.4 (V-)
unnamed: C4.2, R3.2, R6.1, U1.6
unnamed: C4.1, MCP2.7 (B), R3.1, U1.2 (-)
unnamed: C1.1, R1.1, R5.2, U1.3 (+)
unnamed: R5.1, capteur_graphite1.2 (SENSE)
RX: BT1.3 (TX), J4.8
SCK: J2.5, MCP2.2 (SCK)
SCL/A5: J2.1, J3.6, OLED1.3 (SCL)
SDA/A4: J2.2, J3.5, OLED1.4 (SDA)
SI: J2.7, MCP2.3 (SI)
SS: J2.8, MCP2.1 (CS)
TX: BT1.4 (RX), J4.7
Vcc: BT1.1 (Vcc), C3.1, EncodRot2.4 (V+), Flex_sensor2.1 (Vcc), J1.5, J1.8, MCP2.8 (VCC), OLED1.1 (VCC), U1.7 (V+), capteur_graphite1.1 (VCC)

Notes on the sheet:
* Indicates a PWM-capable pin
Amplificateur opérationnel

Board: 2 copper layers, 68.6 x 53.8 mm, 24 parts (0 on the bottom side), 18 nets.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_3.2mm

## Commit log

2024-03-24 Create Code_complet.ino
    Creation of the complete code file
2024-03-24 Update Test_OLED_Encoder.ino
    Update of the encoder file
2024-03-24 Update Test_OLED_Encoder.ino
    Update encoder file
2024-03-24 Update for the switch in the encoder
    Update of the encoder logic with the switch button
2024-03-24 Update code complet
    Update of the description of the project
2024-03-24 Update Test_OLED_Encoder.ino
    Update the name of the action
2024-03-24 Update Code_complet.ino
    Change of some details and creation of a dedicated function for the potentiometer reading
2024-03-24 Flex function in the complete code
    Creation of a dedicated function for the flex sensor
2024-03-24 Update Code_complet.ino
    Update for the flex sensor function
2024-03-24 Update Test_OLED_Encoder.ino
    An error
2024-03-24 Update Code_complet.ino
    Update of the dedicated functions and teh rotary encoder one
2024-03-27 adding the correct version of our PCB
2024-03-27 OLED_Encoder
    Simplification of the method for the encoder, working
2024-04-02 Update Code_complet.ino
    Upload the code for the OLED screen.
2024-04-03 Create 2023-2024-4GP-PeralesRios-LeBlanc.iml
    Automatic modification
2024-04-03 Create .gitignore
    Automatic modification
2024-04-03 Update Code_complet.ino
    Little modifications
2024-04-03 Update Code_complet.ino
    Update for the dedicated functions.
2024-04-03 Update Code_complet.ino
    Ajout potentiomètre
2024-04-04 Update Code_complet.ino
    oui
2024-04-04 Update Code_complet.ino
    Petite modif des variables
2024-04-04 Update Test_Bluetooth.ino
    Big update and cleaning of the code
2024-04-04 Update Code_complet.ino
    Adding the bt module
2024-04-07 Update Code_complet.ino
    adding the calculation of the graphite sensor resistance
2024-04-08 Update Code_complet.ino
    creation of 2 void function to measure the FlexResistance and the GraphiteResistance.
    We don't put these Voids in every loop, but only in the relevant sections.
